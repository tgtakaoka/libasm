;;; Copyright 2026 Tadashi G. Takaoka
;;;
;;; Licensed under the Apache License, Version 2.0 (the "License");
;;; you may not use this file except in compliance with the License.
;;; You may obtain a copy of the License at
;;;
;;;     http://www.apache.org/licenses/LICENSE-2.0
;;;
;;; Unless required by applicable law or agreed to in writing, software
;;; distributed under the License is distributed on an "AS IS" BASIS,
;;; WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
;;; See the License for the specific language governing permissions and
;;; limitations under the License.

;;; page 2
        subx    #$1234
        subx    $12
        subx    5,x
        subx    $1234,y
        subx    [d,sp]
        subx    $1234
        sbex    #$1234
        sbex    $12
        sbex    5,x
        sbex    $1234,y
        sbex    [d,sp]
        sbex    $1234
        sbed    #$1234
        sbed    $12
        sbed    5,x
        sbed    $1234,y
        sbed    [d,sp]
        sbed    $1234
        andx    #$1234
        andx    $12
        andx    5,x
        andx    $1234,y
        andx    [d,sp]
        andx    $1234
        bitx    #$1234
        bitx    $12
        bitx    5,x
        bitx    $1234,y
        bitx    [d,sp]
        bitx    $1234
        eorx    #$1234
        eorx    $12
        eorx    5,x
        eorx    $1234,y
        eorx    [d,sp]
        eorx    $1234
        adex    #$1234
        adex    $12
        adex    5,x
        adex    $1234,y
        adex    [d,sp]
        adex    $1234
        orx     #$1234
        orx     $12
        orx     5,x
        orx     $1234,y
        orx     [d,sp]
        orx     $1234
        addx    #$1234
        addx    $12
        addx    5,x
        addx    $1234,y
        addx    [d,sp]
        addx    $1234
        cped    #$1234
        cped    $12
        cped    5,x
        cped    $1234,y
        cped    [d,sp]
        cped    $1234
        cpey    #$1234
        cpey    $12
        cpey    5,x
        cpey    $1234,y
        cpey    [d,sp]
        cpey    $1234
        cpex    #$1234
        cpex    $12
        cpex    5,x
        cpex    $1234,y
        cpex    [d,sp]
        cpex    $1234
        cpes    #$1234
        cpes    $12
        cpes    5,x
        cpes    $1234,y
        cpes    [d,sp]
        cpes    $1234
        suby    #$1234
        suby    $12
        suby    5,x
        suby    $1234,y
        suby    [d,sp]
        suby    $1234
        sbey    #$1234
        sbey    $12
        sbey    5,x
        sbey    $1234,y
        sbey    [d,sp]
        sbey    $1234
        aded    #$1234
        aded    $12
        aded    5,x
        aded    $1234,y
        aded    [d,sp]
        aded    $1234
        andy    #$1234
        andy    $12
        andy    5,x
        andy    $1234,y
        andy    [d,sp]
        andy    $1234
        bity    #$1234
        bity    $12
        bity    5,x
        bity    $1234,y
        bity    [d,sp]
        bity    $1234
        eory    #$1234
        eory    $12
        eory    5,x
        eory    $1234,y
        eory    [d,sp]
        eory    $1234
        adey    #$1234
        adey    $12
        adey    5,x
        adey    $1234,y
        adey    [d,sp]
        adey    $1234
        ory     #$1234
        ory     $12
        ory     5,x
        ory     $1234,y
        ory     [d,sp]
        ory     $1234
        addy    #$1234
        addy    $12
        addy    5,x
        addy    $1234,y
        addy    [d,sp]
        addy    $1234
        negw    5,x
        negw    -100,y
        negw    [$1234,sp]
        negw    $1234
        comw    5,x
        comw    -100,y
        comw    [$1234,sp]
        comw    $1234
        incw    5,x
        incw    -100,y
        incw    [$1234,sp]
        incw    $1234
        decw    5,x
        decw    -100,y
        decw    [$1234,sp]
        decw    $1234
        lsrw    5,x
        lsrw    -100,y
        lsrw    [$1234,sp]
        lsrw    $1234
        rolw    5,x
        rolw    -100,y
        rolw    [$1234,sp]
        rolw    $1234
        rorw    5,x
        rorw    -100,y
        rorw    [$1234,sp]
        rorw    $1234
        asrw    5,x
        asrw    -100,y
        asrw    [$1234,sp]
        asrw    $1234
        aslw    5,x
        aslw    -100,y
        aslw    [$1234,sp]
        aslw    $1234
        lslw    5,x
        lslw    -100,y
        lslw    [$1234,sp]
        lslw    $1234
        clrw    5,x
        clrw    -100,y
        clrw    [$1234,sp]
        clrw    $1234
        tstw    5,x
        tstw    -100,y
        tstw    [$1234,sp]
        tstw    $1234
        negx
        comx
        incx
        decx
        lsrx
        rolx
        rorx
        asrx
        aslx
        lslx
        negy
        comy
        incy
        decy
        lsry
        roly
        rory
        asry
        asly
        lsly
        clrx
        clry
        tstx
        tsty
        pulcw
        pshcw
        gldaa   $12
        gldaa   5,x
        gldaa   [d,y]
        gldaa   $1234
        gldab   $12
        gldab   5,x
        gldab   [d,y]
        gldab   $1234
        gldd    $12
        gldd    5,x
        gldd    [d,y]
        gldd    $1234
        gldy    $12
        gldy    5,x
        gldy    [d,y]
        gldy    $1234
        gldx    $12
        gldx    5,x
        gldx    [d,y]
        gldx    $1234
        glds    $12
        glds    5,x
        glds    [d,y]
        glds    $1234
        gstaa   $12
        gstaa   5,x
        gstaa   [d,y]
        gstaa   $1234
        gstab   $12
        gstab   5,x
        gstab   [d,y]
        gstab   $1234
        gstd    $12
        gstd    5,x
        gstd    [d,y]
        gstd    $1234
        gsty    $12
        gsty    5,x
        gsty    [d,y]
        gsty    $1234
        gstx    $12
        gstx    5,x
        gstx    [d,y]
        gstx    $1234
        gsts    $12
        gsts    5,x
        gsts    [d,y]
        gsts    $1234
        btas    $12,#$34
        btas    $1234,#$34
        btas    5,x,#$34
        btas    100,y,#$34
;;; transfer/exchange
        tfr     ccrl,a
        tfr     ccrl,b
        tfr     ccrl,ccrl
        tfr     a,ccrl
        tfr     b,ccrl
        tfr     d,ccrl
        tfr     xl,a
        tfr     xl,b
        tfr     xl,ccrl
        tfr     yl,a
        tfr     yl,b
        tfr     yl,ccrl
        tfr     spl,a
        tfr     spl,b
        tfr     spl,ccrl
        tfr     ccrh,a
        tfr     xh,a
        tfr     yh,a
        tfr     sph,a
        tfr     a,ccrh
        tfr     ccrw,ccrw
        tfr     d,ccrw
        tfr     x,ccrw
        tfr     y,ccrw
        tfr     sp,ccrw
        tfr     ccrw,d
        tfr     a,xh
        tfr     b,xl
        tfr     ccrw,x
        tfr     a,yh
        tfr     b,yl
        tfr     ccrw,y
        tfr     a,sph
        tfr     b,spl
        tfr     ccrw,sp
        sex     ccrl,d
        sex     ccrl,x
        sex     ccrl,y
        sex     ccrl,sp
        exg     ccrl,a
        exg     ccrl,b
        exg     ccrl,ccrl
        exg     ccrl,d
        exg     ccrl,x
        exg     ccrl,y
        exg     ccrl,sp
        exg     a,ccrl
        exg     b,ccrl
        exg     d,ccrl
        exg     x,ccrl
        exg     y,ccrl
        exg     sp,ccrl
        exg     ccrh,a
        exg     xh,a
        exg     yh,a
        exg     sph,a
        exg     a,ccrh
        exg     ccrw,ccrw
        exg     d,ccrw
        exg     x,ccrw
        exg     y,ccrw
        exg     sp,ccrw
        exg     ccrw,d
        exg     a,xh
        exg     b,xl
        exg     ccrw,x
        exg     a,yh
        exg     b,yl
        exg     ccrw,y
        exg     a,sph
        exg     b,spl
        exg     ccrw,sp
;;; move
        movw    #$1234,$9abc
        movw    #$1234,7,y
        movw    #$1234,200,x
        movw    #$1234,$4321,sp
        movw    #$1234,[d,y]
        movw    #$1234,[$4321,x]
        movw    #$1234,d,y
        movw    #$1234,4,sp-
        movw    $5678,$9abc
        movw    $5678,7,y
        movw    $5678,200,x
        movw    $5678,$4321,sp
        movw    $5678,[d,y]
        movw    $5678,[$4321,x]
        movw    $5678,d,y
        movw    $5678,4,sp-
        movw    1,x,$9abc
        movw    1,x,7,y
        movw    1,x,200,x
        movw    1,x,$4321,sp
        movw    1,x,[d,y]
        movw    1,x,[$4321,x]
        movw    1,x,d,y
        movw    1,x,4,sp-
        movw    -100,y,$9abc
        movw    -100,y,7,y
        movw    -100,y,200,x
        movw    -100,y,$4321,sp
        movw    -100,y,[d,y]
        movw    -100,y,[$4321,x]
        movw    -100,y,d,y
        movw    -100,y,4,sp-
        movw    $1234,sp,$9abc
        movw    $1234,sp,7,y
        movw    $1234,sp,200,x
        movw    $1234,sp,$4321,sp
        movw    $1234,sp,[d,y]
        movw    $1234,sp,[$4321,x]
        movw    $1234,sp,d,y
        movw    $1234,sp,4,sp-
        movw    [d,x],$9abc
        movw    [d,x],7,y
        movw    [d,x],200,x
        movw    [d,x],$4321,sp
        movw    [d,x],[d,y]
        movw    [d,x],[$4321,x]
        movw    [d,x],d,y
        movw    [d,x],4,sp-
        movw    [$1234,y],$9abc
        movw    [$1234,y],7,y
        movw    [$1234,y],200,x
        movw    [$1234,y],$4321,sp
        movw    [$1234,y],[d,y]
        movw    [$1234,y],[$4321,x]
        movw    [$1234,y],d,y
        movw    [$1234,y],4,sp-
        movw    a,x,$9abc
        movw    a,x,7,y
        movw    a,x,200,x
        movw    a,x,$4321,sp
        movw    a,x,[d,y]
        movw    a,x,[$4321,x]
        movw    a,x,d,y
        movw    a,x,4,sp-
        movw    2,x+,$9abc
        movw    2,x+,7,y
        movw    2,x+,200,x
        movw    2,x+,$4321,sp
        movw    2,x+,[d,y]
        movw    2,x+,[$4321,x]
        movw    2,x+,d,y
        movw    2,x+,4,sp-
        movw    3,-y,$9abc
        movw    3,-y,7,y
        movw    3,-y,200,x
        movw    3,-y,$4321,sp
        movw    3,-y,[d,y]
        movw    3,-y,[$4321,x]
        movw    3,-y,d,y
        movw    3,-y,4,sp-
        movb    #$12,$9abc
        movb    #$12,7,y
        movb    #$12,200,x
        movb    #$12,$4321,sp
        movb    #$12,[d,y]
        movb    #$12,[$4321,x]
        movb    #$12,d,y
        movb    #$12,4,sp-
        movb    $5678,$9abc
        movb    $5678,7,y
        movb    $5678,200,x
        movb    $5678,$4321,sp
        movb    $5678,[d,y]
        movb    $5678,[$4321,x]
        movb    $5678,d,y
        movb    $5678,4,sp-
        movb    1,x,$9abc
        movb    1,x,7,y
        movb    1,x,200,x
        movb    1,x,$4321,sp
        movb    1,x,[d,y]
        movb    1,x,[$4321,x]
        movb    1,x,d,y
        movb    1,x,4,sp-
        movb    -100,y,$9abc
        movb    -100,y,7,y
        movb    -100,y,200,x
        movb    -100,y,$4321,sp
        movb    -100,y,[d,y]
        movb    -100,y,[$4321,x]
        movb    -100,y,d,y
        movb    -100,y,4,sp-
        movb    $1234,sp,$9abc
        movb    $1234,sp,7,y
        movb    $1234,sp,200,x
        movb    $1234,sp,$4321,sp
        movb    $1234,sp,[d,y]
        movb    $1234,sp,[$4321,x]
        movb    $1234,sp,d,y
        movb    $1234,sp,4,sp-
        movb    [d,x],$9abc
        movb    [d,x],7,y
        movb    [d,x],200,x
        movb    [d,x],$4321,sp
        movb    [d,x],[d,y]
        movb    [d,x],[$4321,x]
        movb    [d,x],d,y
        movb    [d,x],4,sp-
        movb    [$1234,y],$9abc
        movb    [$1234,y],7,y
        movb    [$1234,y],200,x
        movb    [$1234,y],$4321,sp
        movb    [$1234,y],[d,y]
        movb    [$1234,y],[$4321,x]
        movb    [$1234,y],d,y
        movb    [$1234,y],4,sp-
        movb    b,sp,$9abc
        movb    b,sp,7,y
        movb    b,sp,200,x
        movb    b,sp,$4321,sp
        movb    b,sp,[d,y]
        movb    b,sp,[$4321,x]
        movb    b,sp,d,y
        movb    b,sp,4,sp-
        movb    2,x+,$9abc
        movb    2,x+,7,y
        movb    2,x+,200,x
        movb    2,x+,$4321,sp
        movb    2,x+,[d,y]
        movb    2,x+,[$4321,x]
        movb    2,x+,d,y
        movb    2,x+,4,sp-
        movb    3,-y,$9abc
        movb    3,-y,7,y
        movb    3,-y,200,x
        movb    3,-y,$4321,sp
        movb    3,-y,[d,y]
        movb    3,-y,[$4321,x]
        movb    3,-y,d,y
        movb    3,-y,4,sp-
;;; Local Variables:
;;; mode: asm
;;; End:
;;; vim: set ft=asm:
